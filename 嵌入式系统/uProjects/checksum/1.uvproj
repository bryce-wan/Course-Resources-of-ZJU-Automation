# Keil uVision project 1.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Microchip
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: 1
  c flags: Optimize=8 SizeSpeed=1
  c include: D:\Keil_v5\C51;D:\Keil_v5\C51\INC
  group Source Group 1
    ./: checksum.a51
